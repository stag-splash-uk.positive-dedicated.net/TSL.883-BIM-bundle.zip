Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0001
Time: 2018-10-30T18:13:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160314_0715(x64) - Exporter 16.0.1124.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 30 18:13:01 2018 * Host: DESKTOP-HSFH8JC * Database: C:\Users\C559~1\AppData\Local\Temp\{167416A6-111B-47E0-859B-3D594A8E2541}\ifc * Database version: 5507 * Database creation date: Tue Oct 30 18:13:01 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 30 18:13:01 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 30 18:13:01 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFurnishingElement: Black, SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883:Black:309762
In: Level 1
Type - ElementType: Black; Classification: D2010400 Sinks (Uniformat); Material: Brushed Black
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - Author: TheSplashLab; BIMObjectName: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; ManufacturerName: TheSplashLab; ManufacturerURL: https://thesplashlab.com/; NBSDescription: n/a; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: Pr_40_20_87_98; NBSTypeID: n/a; Revision: 0; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin taps; Uniclass2015Version: UK_NBS_Uniclass2015_04_18; Version: 1
Type - Identity Data - Assembly Code: D2010400; Assembly Description: Sinks; Manufacturer: TheSplashLab; Model: TSL-883; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Name: Black; URL: https://thesplashlab.com/product/tsl-881-capacitive-sensor-tap/
Type - Materials and Finishes - HousingMaterial: Brushed Black
Type - Other - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_87_98; CodePerformance: n/a; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; Features: n/a; Grade: n/a; ModelNumber: n/a; ModelReference: n/a; Name: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; NominalHeight: 150 mm; NominalLength: 45 mm; NominalWidth: 16.3 mm; ReplacementCost: n/a; Shape: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: TheSplashLab
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.00970904 m2; Volume: 0.0000135102 m3
Other - Category: Furniture; Schedule Level: Level: Level 1; AssetIdentifier: n/a; BarCode: n/a; Family: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Black; Family and Type: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Black; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; Type: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Black; Type Id: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Black; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction

# IfcFurnishingElement: Brass, SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883:Brass:309737
In: Level 1
Type - ElementType: Brass; Classification: D2010400 Sinks (Uniformat); Material: Brushed Brass
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - Author: TheSplashLab; BIMObjectName: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; ManufacturerName: TheSplashLab; ManufacturerURL: https://thesplashlab.com/; NBSDescription: n/a; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: Pr_40_20_87_98; NBSTypeID: n/a; Revision: 0; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin taps; Uniclass2015Version: UK_NBS_Uniclass2015_04_18; Version: 1
Type - Identity Data - Assembly Code: D2010400; Assembly Description: Sinks; Manufacturer: TheSplashLab; Model: TSL-883; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Name: Brass; URL: https://thesplashlab.com/product/tsl-881-capacitive-sensor-tap/
Type - Materials and Finishes - HousingMaterial: Brushed Brass
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Fixed; CodePerformance: n/a; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; Features: n/a; Grade: n/a; ModelNumber: n/a; ModelReference: n/a; Name: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; NominalHeight: 150 mm; NominalLength: 45 mm; NominalWidth: 16.3 mm; ReplacementCost: n/a; Shape: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: TheSplashLab
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.00970904 m2; Volume: 0.0000135102 m3
Other - Schedule Level: Level: Level 1; AssetIdentifier: n/a; BarCode: n/a; Family: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Brass; Family and Type: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Brass; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; Type: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Brass; Type Id: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Brass; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction

# IfcFurnishingElement: Bronze, SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883:Bronze:309708
In: Level 1
Type - ElementType: Bronze; Classification: D2010400 Sinks (Uniformat); Material: Brushed Bronze
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - Author: TheSplashLab; BIMObjectName: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; ManufacturerName: TheSplashLab; ManufacturerURL: https://thesplashlab.com/; NBSDescription: n/a; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: Pr_40_20_87_98; NBSTypeID: n/a; Revision: 0; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin taps; Uniclass2015Version: UK_NBS_Uniclass2015_04_18; Version: 1
Type - Identity Data - Assembly Code: D2010400; Assembly Description: Sinks; Manufacturer: TheSplashLab; Model: TSL-883; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Name: Bronze; URL: https://thesplashlab.com/product/tsl-881-capacitive-sensor-tap/
Type - Materials and Finishes - HousingMaterial: Brushed Bronze
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Fixed; CodePerformance: n/a; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; Features: n/a; Grade: n/a; ModelNumber: n/a; ModelReference: n/a; Name: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; NominalHeight: 150 mm; NominalLength: 45 mm; NominalWidth: 16.3 mm; ReplacementCost: n/a; Shape: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: TheSplashLab
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.00970904 m2; Volume: 0.0000135102 m3
Other - AssetIdentifier: n/a; BarCode: n/a; Family: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Bronze; Family and Type: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Bronze; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Bronze; Type Id: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Bronze; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction

# IfcFurnishingElement: Copper, SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883:Copper:309771
In: Level 1
Type - ElementType: Copper; Classification: D2010400 Sinks (Uniformat); Material: Brushed Copper
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - Author: TheSplashLab; BIMObjectName: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; ManufacturerName: TheSplashLab; ManufacturerURL: https://thesplashlab.com/; NBSDescription: n/a; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: Pr_40_20_87_98; NBSTypeID: n/a; Revision: 0; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin taps; Uniclass2015Version: UK_NBS_Uniclass2015_04_18; Version: 1
Type - Identity Data - Assembly Code: D2010400; Assembly Description: Sinks; Manufacturer: TheSplashLab; Model: TSL-883; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Name: Copper
Type - Materials and Finishes - HousingMaterial: Brushed Copper
Type - Other - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_87_98; CodePerformance: n/a; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; Features: n/a; Grade: n/a; ModelNumber: n/a; ModelReference: n/a; Name: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; NominalHeight: 150 mm; NominalLength: 45 mm; NominalWidth: 16.3 mm; ReplacementCost: n/a; Shape: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: TheSplashLab
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.00970904 m2; Volume: 0.0000135102 m3
Other - Category: Furniture; Schedule Level: Level: Level 1; AssetIdentifier: n/a; BarCode: n/a; Family: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Copper; Family and Type: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Copper; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; Type: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Copper; Type Id: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Copper; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction

# IfcFurnishingElement: Satin, SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883:Satin:309780
In: Level 1
Type - ElementType: Satin; Classification: D2010400 Sinks (Uniformat); Material: Stainless Steel
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - Author: TheSplashLab; BIMObjectName: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; ManufacturerName: TheSplashLab; ManufacturerURL: https://thesplashlab.com/; NBSDescription: n/a; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: Pr_40_20_87_98; NBSTypeID: n/a; Revision: 0; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin taps; Uniclass2015Version: UK_NBS_Uniclass2015_04_18; Version: 1
Type - Identity Data - Assembly Code: D2010400; Assembly Description: Sinks; Manufacturer: TheSplashLab; Model: TSL-883; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Name: Satin; URL: https://thesplashlab.com/product/tsl-881-capacitive-sensor-tap/
Type - Materials and Finishes - HousingMaterial: Stainless Steel
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Fixed; CodePerformance: n/a; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; Features: n/a; Grade: n/a; ModelNumber: n/a; ModelReference: n/a; Name: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883; NominalHeight: 150 mm; NominalLength: 45 mm; NominalWidth: 16.3 mm; ReplacementCost: n/a; Shape: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: TheSplashLab
Constraints - Elevation: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.00970904 m2; Volume: 0.0000135102 m3
Other - Schedule Level: Level: Level 1; AssetIdentifier: n/a; BarCode: n/a; Family: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Satin; Family and Type: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Satin; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; Type: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Satin; Type Id: SanitaryEquipment_Lovair_Capacitive-sensor-tap_TSL-883: Satin; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction
